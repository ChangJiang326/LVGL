<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\remote_control_lvgl.ewp</path>
  </project>
  <batchBuild />
</workspace>
